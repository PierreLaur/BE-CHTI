# Keil uVision project dft2.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dft2 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB,USE_FULL_LL_DRIVER
  c misc: --C99
  c include: .\GFSSP72
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group source
    ./: carre.s dft.c m2.s arghh.asm callback.s etat.h etat.inc
    ./test_DFT/: trigo.asm
  group sys
    ../common/: startup-rvds.s
  group drivers
    ../common/GFSSP72/: gfssp72.lib
  group Tests
    ./test_DFT/: f23p-26_f24p-116.asm f1p-45.asm f17p30_f18p135.asm
