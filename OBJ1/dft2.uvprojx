# Keil uVision project dft2.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: dft2
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group source
    ./: carre.s dft.c m2.s
    ./test_DFT/: trigo.asm
  group sys
    ./: startup-rvds.s
  group drivers
    ./GASSP72/: gassp72.lib
  group Tests
    ./test_DFT/: f23p-26_f24p-116.asm f1p-45.asm f17p30_f18p135.asm
